# Keil uVision project Motor_MPU6050_Control.uvprojx, settings and files
target Target 1 (6210000::V6.21::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Motor_MPU6050_Control +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=6 v6LangP=3 wLevel=3
  c include: ..\..\Driver\Header;..\..\Common\Header
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Driver_Source
    ../../Driver/Source/: gpio_driver.c i2c_driver.c rcc_driver.c rtos.c systick_driver.c timer_driver.c usart_driver.c cortexm3_irq.c
  group Common_Source
    ../../Common/Source/: millisecond.c motor_driver.c mpu6050_driver.c ringbuffer.c ultrasonic.c
  group Main_Source
    ../../Main/: Motor_MPU6050_Control.c
software components: CMSIS:CORE 5.6.0, Device:Startup 1.0.0
